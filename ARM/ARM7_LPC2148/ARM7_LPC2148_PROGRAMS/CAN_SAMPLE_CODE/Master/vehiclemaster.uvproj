# Keil uVision project vehiclemaster.uvproj, settings and files
target Target 1 ()
  device: LPC2129 Philips
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: vehiclemaster +hex
  group Source Group 1
    ./: Startup.s master.c
